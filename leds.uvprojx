# Keil uVision project leds.uvprojx, settings and files
target archpro (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: leds +hex
  c flags: Optim=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group main
    ./: main.c
  group net
    ./: net_task.c
  group status_leds
    ./: leds_control.c
  group timer
    ./: half_sec_timer.c
  group RTC
    ./: rtc_control.c
  group display
    ./: display_task.c
  group buttons
    ./: buttons.c IAP.c
  group ::CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    d:/Keil_v5/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS_RTX/LIB/ARM/: RTX_CM3.lib
  group ::CMSIS Driver
    d:/Keil_v5/ARM/PACK/Keil/LPC1700_DFP/2.0.0/RTE_Driver/: EMAC_LPC17xx.c I2C_LPC17xx.c SSP_LPC17xx.c
    d:/Keil_v5/ARM/PACK/Keil/MDK-Middleware/6.2.0/Network/Driver/: PHY_DP83848C.c
  group ::Device
    RTE/Device/LPC1768/: RTE_Device.h startup_LPC17xx.s system_LPC17xx.c
    d:/Keil_v5/ARM/PACK/Keil/LPC1700_DFP/2.0.0/RTE_Driver/: GPIO_LPC17xx.c PIN_LPC17xx.c GPDMA_LPC17xx.c
  group ::Network
    RTE/Network/: Net_Config.c Net_Config_DNS_Client.h Net_Config_ETH_0.h Net_Config_UDP.h Net_Config_SNTP_Client.h
    d:/Keil_v5/ARM/PACK/Keil/MDK-Middleware/6.2.0/Network/Lib/ARM/: Net_CM3_L.lib
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, Network:CORE 6.2.0, Network:Interface:ETH 6.2.0, Network:Service:DNS Client 6.2.0, Network:Service:SNTP Client 6.2.0, Network:Socket:UDP 6.2.0, CMSIS Driver:Ethernet MAC 2.01, CMSIS Driver:Ethernet PHY:DP83848C 6.00, CMSIS Driver:I2C 2.01, CMSIS Driver:SPI:SSP 2.01, Device:GPDMA 1.00, Device:GPIO 1.00, Device:PIN 1.00, Device:Startup 1.0.0
